# Keil uVision project template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o  ..\OBJ\TEST.bin ..\OBJ\template.axf
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\FWLIB\inc;..\CORE;..\DELAY;..\HARDWARE\LED;..\TFT
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c usart.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group DELAY
    ../DELAY/: delay.c
  group TFT
    ../TFT/: tft.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
